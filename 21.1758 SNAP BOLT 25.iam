# Autodesk Inventor assembly: 21.1758 SNAP BOLT 25
## iProperties
Created: 2007-03
Part Number: 21.1758 SNAP BOLT 25
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
